# Keil uVision project STM32L476.uvprojx, settings and files
target lr1110_lr1120_tcxo (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L476_lr11xx
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: STM32L476xx, SXTOOLS_McuFamily_STM32L4xx, SXLIB_LOG_LEVEL=2000, USE_FULL_LL_DRIVER, CONFIG_SYS_CLOCK_TICKS_PER_SEC=1000, CONFIG_SMTC_DEMO_TCXO_STARTUP_TIME=5
  c include: ..\..\lib\stm32cubel4subset\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\lib\sxlib2\include\Rtos\bare_metal\model\synchronous;..\..\lib\sxlib2\include\model\synchronous;..\..\lib\sx_comp\src;..\..\lib\sx126x_comp\src;..\..\lib\sx128x_comp\src;..\..\lib\lr11xx_comp\src;..\..\lib\sx126x_driver\src;..\..\lib\sx128x_driver\src;..\..\lib\lr11xx_driver\src;..\..\lib\sxlib2\include\Generic;..\..\lib\sxlib2\include\Rtos\bare_metal;..\..\lib\sxlib2\include\McuHal\stm32cube;..\..\platform\bare_metal\system\inc;..\..\lib\smtc_ral\src;..\..\lib\smtc_ralf\src;..\..\lib\utils;..\..\platform\inc;..\..\platform\bare_metal\stm32cube\shield;..\..\platform\bare_metal\stm32cube\nucleo64\STM32L4xx;..\..\lib\sxlib2\include\Generic\Extern\DmTft;..\..\lib\sx126x_lr_fhss_driver\src;..\..\lib\lr_fhss_driver\src;..\..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group main
    ../../: README.md
    ../../platform/bare_metal/: main_rtx5.c prepare_interface.c
  group shield_sx126x
    ../../platform/bare_metal/stm32cube/shield/sx126x/: identify_sx126x.c smtc_shield.c
    ../../platform/bare_metal/system_files/Nucleo64/STM32L4xx/BoardVariant/e406v03a/: BoardVariant_interrupts.c
  group shield_lr1110_lr1120_tcxo
    ../../platform/bare_metal/stm32cube/shield/lr1110_lr1120_tcxo/: identify_lr1110_lr1120_tcxo.c
  group shield_lr1121_xtal
    ../../platform/bare_metal/stm32cube/shield/lr1121_xtal/: identify_lr1121_xtal.c
  group shield_lr11xx
    ../../platform/bare_metal/stm32cube/shield/lr11xx/: smtc_shield.c
    ../../platform/bare_metal/system_files/Nucleo64/STM32L4xx/BoardVariant/e516v02a/: BoardVariant_interrupts.c
  group main_
    ../../platform/bare_metal/: main_single_radio.c
  group misc_sx126x
    ../../lib/sxlib2/src/Generic/sxlib/Radio/Sx126x/: Generic_Radio_Sx126x_driver_hal.c Generic_Radio_Sx126x_driver_hal_timed.c
  group misc_lr11xx
    ../../lib/sxlib2/src/Generic/sxlib/Radio/Lr11xx/: Generic_Radio_Lr11xx_driver_hal.c Generic_Radio_Lr11xx_driver_hal_timed.c
  group radio_driver_bsp_sx126x
    ../../platform/src/: sx126x_comp_hal.c sx126x_comp_hal_gpio_antenna_switch.c
  group radio_driver_bsp_lr11xx
    ../../platform/src/: lr11xx_comp_hal.c
  group sx_comp
    ../../lib/sx_comp/src/: sx_comp.c
  group sx_comp_sx126x
    ../../lib/sx126x_comp/src/: sx126x_comp.c sx126x_comp_samples.c sx126x_comp_generic.c
  group sx_comp_lr11xx
    ../../lib/lr11xx_comp/src/: lr11xx_comp.c lr11xx_comp_generic.c
  group sx126x_driver
    ../../lib/sx126x_driver/src/: sx126x.c
  group sx126x_lr_fhss_support
    ../../lib/sx126x_driver/src/: lr_fhss_mac.c sx126x_lr_fhss.c
  group lr11xx_driver
    ../../lib/lr11xx_driver/src/: lr11xx_radio.c lr11xx_regmem.c lr11xx_system.c
  group lr11xx_lr_fhss_support
    ../../lib/lr11xx_driver/src/: lr11xx_lr_fhss.c
  group sxlib
    ../../lib/sxlib2/src/Generic/sxlib/Timing/OneShotTimerBase/: Generic_Timing_OneShotTimerBase.c
    ../../lib/sxlib2/src/Rtos/bare_metal/sxlib/Debug/Assert/: Rtos_Debug_Assert.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Gpio/Led/: McuHal_Gpio_Led.c
    ../../lib/sxlib2/src/Rtos/bare_metal/sxlib/Timing/SystemTime/: Rtos_Timing_SystemTime.c
    ../../lib/sxlib2/src/Generic/sxlib/Debug/Log/: Generic_Debug_Log.c Generic_Debug_vLog.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Gpio/Output/: McuHal_Gpio_Output.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Gpio/Input/: McuHal_Gpio_Input.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/System/irq_line/: McuHal_System_irq_line.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Comm/spi_device/: McuHal_Comm_spi_device_fast.c McuHal_Comm_spi_device_optimize.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Comm/serial/: McuHal_Comm_serial.c
    ../../lib/sxlib2/src/Generic/sxlib/Timing/SystemTime/: Generic_Timing_SystemTime.c
    ../../lib/sxlib2/src/Rtos/bare_metal/sxlib/Timing/sync_timer/: Rtos_Timing_sync_timer.c
    ../../lib/sxlib2/src/McuHal/stm32cube/sxlib/Data/Random/: McuHal_Data_Random.c
    ../../lib/sxlib2/src/Rtos/bare_metal/model/synchronous/sxlib/Radio/event_handler/: Rtos_model_Radio_event_handler.c
    ../../lib/sxlib2/src/Generic/sxlib/Radio/event_handler/: Generic_Radio_event_handler_register.c
  group mcuhal_stm32cube
    ../../lib/stm32cubel4subset/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_spi.c stm32l4xx_ll_gpio.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_ll_rcc.c
  group board_nucleo64
    ../../platform/bare_metal/stm32cube/nucleo64/STM32L4xx/: smtc_board.c stm32l4xx_clock_msi_48mhz_no_pll.c
  group Device_bare_metal
    ../../platform/bare_metal/system_files/STM32L4xx/Rtos/Rtx5/: Rtos_interrupts.c
    ./RTE/Device/STM32L476RGTx/: Arch_HalSysTick.s
  group demo_sx126x_lr_fhss_ping
    ../../src/demos/sx126x_lr_fhss_ping/: sx126x_lr_fhss_ping_start.c sx126x_lr_fhss_ping_sync.c sx126x_lr_fhss_ping.c
  group demo_lr11xx_lr_fhss_ping
    ../../src/demos/lr11xx_lr_fhss_ping/: lr11xx_lr_fhss_ping_start.c lr11xx_lr_fhss_ping_sync.c lr11xx_lr_fhss_ping.c
target sx126x (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: STM32L476_sx126x
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1121_xtal (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: STM32L476_lr11xx
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 1.3.1
